FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI_${PN} += "file://netfilter.cfg"
